## config/boards/shields/poco39/Kconfig.defconfig
```kconfig
if SHIELD_POCO39

config ZMK_KEYBOARD_NAME
    default "Poco39"

config ZMK_USB_LOGGING
    default n

endif # SHIELD_POCO39
```
